SRCREV_ti-soc = "8e74d47616a20eaa23ca692f4bbbf917a236ed94"

PR_append = "_psdkla_0"