FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR_append = "_psdkla_1"
