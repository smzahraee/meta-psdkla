IMAGE_INSTALL += " \
		  kmod \
"
