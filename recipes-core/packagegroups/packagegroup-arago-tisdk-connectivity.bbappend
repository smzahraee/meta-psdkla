PR_append = "_psdkla0"

WLAN_COMMON_append_j7-evm = "\
    linux-firmware-iwlwifi-9260 \
    linux-firmware-ibt-18 \
"
