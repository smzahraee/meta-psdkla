PR:append = "_psdkla_0"

RDEPENDS:${PN} += " \
    tisdk-install \
    ti-tisdk-setup \
    unshallow-repositories \
"
