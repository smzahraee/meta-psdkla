BBCLASSEXTEND = "native nativesdk"

PR_append = "_psdkla"
