UTILS_remove_j7200-evm = " \
    pru-icss-src \
"