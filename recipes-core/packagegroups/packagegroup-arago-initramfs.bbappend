INITRD_APPS_append = " \
	ti-heartbeat-ivi-vm \
"

PR_append = "_psdkla_1"
