PR_append = "_psdkla"

RDEPENDS_${PN}_append = " \
    gstreamer1.0-rtsp-server \
"
