PR_append = "_psdkla_1"

QT5_DEMOS += "\
    qtdeclarative-examples \
"
