PR_append = "_psdkla_1"

EXTRA_QMAKEVARS_PRE += "QT_BUILD_PARTS+=examples"
EXTRA_QMAKEVARS_PRE += "QT_BUILD_PARTS-=qml-debug"
