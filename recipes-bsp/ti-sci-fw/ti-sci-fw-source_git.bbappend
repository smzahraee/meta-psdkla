SRCREV_imggen_am65xx-evm = "5cad1fe257e8d9c9d30a53d721954a203a16e506"

PR_append = "_psdkla_1"