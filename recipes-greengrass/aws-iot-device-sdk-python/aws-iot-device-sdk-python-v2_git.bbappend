# Fix this SRCREV to the latest at the release time
# 28-Oct-2020

SRCREV = "e55e0654fe76b1a634a649530e18a022dfbd5468"
PR_append = "_psdkla_3"
