# Fix this SRCREV to the latest at the release time
# 15-Jul-2021

SRCREV = "b2662cc08e1160f533fdf22a868f12b51baa965e"
PR_append = "_psdkla_4"
