PR_append = ".arago1"

SRC_URI = "https://ftp.osuosl.org/pub/osgeo/download/libtiff/tiff-${PV}.tar.gz"
