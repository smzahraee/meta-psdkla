FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_j7-evm = "file://0001-Avoiding-Failure-to-allocate-required-memory.patch"

