PACKAGECONFIG_append = " \
                   tracer-hooks \
"

PR_append = "_psdkla_0"
